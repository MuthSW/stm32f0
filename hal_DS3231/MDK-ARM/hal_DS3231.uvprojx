# Keil uVision project hal_DS3231.uvprojx, settings and files
target hal_DS3231 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: hal_DS3231
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F051x8
  c misc: --C99
  c include: ../Inc;../DS3231;C:/Users/ad/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Drivers/STM32F0xx_HAL_Driver/Inc;C:/Users/ad/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;C:/Users/ad/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Drivers/CMSIS/Include;C:/Users/ad/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Drivers/CMSIS/Device/ST/STM32F0xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F0xx_HAL_Driver
    C:/Users/ad/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_rcc.c stm32f0xx_hal_cortex.c stm32f0xx_hal.c stm32f0xx_hal_dma.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_pwr.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_spi.c
  group Drivers/CMSIS
    C:/Users/ad/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Drivers/CMSIS//Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Application/User
    ../Src/: stm32f0xx_hal_msp.c stm32f0xx_it.c i2c.c gpio.c spi.c main.c rtc.c tim.c
  group Application/MDK-ARM
    ./: startup_stm32f051x8.s
  group DS3231
    ../DS3231/: i2cutil.c rtcutil.c
software components: CMSIS:CORE 4.1.0
